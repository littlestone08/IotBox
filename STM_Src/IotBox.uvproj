# Keil uVision project IotBox.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: IotBox
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\User;.\FWLib\inc;.\User\CQ;.\User\ToolCase
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c core_cm3.h
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group User
    ./User/: stm32f10x_it.c InitCPU.c Global.c USART2Func.c USART1Func.c USART3Func.c Test.c BoxActionSensor.c Retarget.c Serial.c rtx_main.cpp bsp.cpp RF200_DRV.c
    ./User/CQ/: CQ1.c CQ2.c CQ3.c
    ./User/ToolCase/: ToolCase.cpp
  group FWLib
    ./FWLib/src/: stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_gpio.c misc.c
  group RTX
    ./RTX/: RTX_Conf_CM.c
